# Keil uVision project BH-STM32.uvprojx, settings and files
target beep (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 流水灯 +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\sys;..\..\User\usart;..\..\User\delay;..\..\User\led;..\..\User\Key;..\..\User\i2c;..\..\User\OLED0561;..\..\User\DHT11;..\..\User\iwdg;..\..\User\wwdg;..\..\User\RELAY
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/beep/: bsp_beep.c
    ../../User/usart/: usart.c
    ../../User/sys/: sys.c
    ../../User/delay/: delay.c
    ../../User/led/: bsp_led.c
    ../../User/Key/: bsp_key.c
    ../../User/i2c/: i2c.c
    ../../User/OLED0561/: oled0561.c
    ../../User/DHT11/: dht11.c
    ../../User/iwdg/: iwdg.c
    ../../User/wwdg/: wwdg.c
    ../../User/RELAY/: relay.c
  group DOC
    ../../Doc/: readme.txt
